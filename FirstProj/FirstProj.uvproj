# Keil uVision project FirstProj.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: FirstProj +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c yourapp.c yourapp.h hal_board_cfg.h
  group Common Group
    ../common/: hal_delay.c hal_lcd1602.c hal_timer.c hal_led.c hal_key.c hal_serial.c util_num2str.c sys_core.c
